# Repository luooove/XProject

## EAGLE design Eagle/arduino_miniuno/arduino_miniuno.brd

Parts:
C1, C2: 100n; C0603-ROUND
C3: 1u; C0603-ROUND
C5: 100nF; C0402
C6, C8: 22pF; C0402
C7: 10nF; C0402
D1, D2: CESD5V0AP; SOT23
D3: M7; SMB
F1: MF-MSMF050-2 500mA; L1812
J3: 1X7P-2.54-2.54-6.0-90D-1; 7P-2.54-65/35MIL
L: YELLOW; CHIP-LED0805
L1: BLM21; 0805
PC1, PC2: 47u; PANASONIC_D
PCB1: ARDUINO_UNO
PWR: GREEN; LED-0603
Q1, Q2: S8550; SOT23
R1, R2, R3, R4, R5: 1k; R0402
RN1: 10K; CAY16
RN2: 1K; CAY16
RX: RED; LED-0603
T1: FDN340P; SOT-23
TX: RED; LED-0603
U1: CH340T; SSOP20
U2: NCP1117ST50T3G; SOT223
U3: LP2985-33DBVR; SOT23-DBV
U5: LMV358IDGKR; MSOP08
U$3: PRO-MINI-2
X1: 12MHz; HC49UP
X2: USB-B_TH; PN61729
X3: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
Z1, Z2: CG0603MLC-05E; CT/CN0603

Connections:
3.3V: PCB1.3.3V
5V: C5.2, D2.1, J3.4, PWR.+, Q1.2 (E), Q2.2 (E), U1.19 (VCC)
+3V3: C3.2, U3.5 (OUT), U5.2 (-IN)
+5V: C1.2, C2.2, PC2.+, T1.2 (S), U2.2 (OUT), U2.4 (OUT), U3.1 (IN), U3.3 (ON/!OFF), U5.8 (V+)
A0: PCB1.A0, U$3.A0
A1: PCB1.A1, U$3.A1
A2: PCB1.A2, U$3.A2
A3: PCB1.A3, U$3.A3
A4: PCB1.A4, PCB1.SDA (27(SDA)), U$3.A4
A5: PCB1.A5, PCB1.SCL (28(SCL)), U$3.A5
A6: U$3.A6
A7: U$3.A7
CMP: RN1.1, RN1.2 (1), U5.3 (+IN)
CTS: J3.5, U1.11 (CTS#)
D2: PCB1.2, U$3.D2
D3: PCB1.3 (~3), U$3.D3
D4: PCB1.4, U$3.D4
D5: PCB1.5 (~5), U$3.D5
D6: PCB1.6 (~6), U$3.D6
D7: PCB1.7, U$3.D7
D8: PCB1.8, U$3.D8
D9: PCB1.9 (~9), U$3.D9
D10: PCB1.10 (~10), U$3.D10
D11: PCB1.11 (~11), U$3.D11
D12: PCB1.12, U$3.D12
D13: PCB1.13, U$3.D13
D+: U1.6 (UD+), X2.3, Z1.1
D-: U1.7 (UD-), X2.2, Z2.1
DTR: J3.1, U1.15 (DTR#), U$3.DTR
GATE_CMD: T1.3 (G), U5.1 (OUT)
GND: C1.1, C2.1, C3.1, C5.1, C6.1, C7.2, C8.1, D1.3, D2.3, J3.6, L.C, L1.1, PC1.-, PC2.-, PCB1.GND, PCB1.GND., PCB1.GND.., R3.1, R4.1, R5.1, RN1.7 (2), U1.8 (GND), U2.1 (GND/ADJ), U3.2 (GND), U5.4 (V-), U$3.GND, U$3.GND1 (GND2), U$3.GND2 (GND3), U$3.GND3 (GND4), X2.4, X3.1, X3.3
L13: RN2.8 (2), U5.6 (-IN), U5.7 (OUT)
unnamed: Q1.3 (C), TX.+
unnamed: Q2.3 (C), RX.+
unnamed: L.A, RN2.1
unnamed: C6.2, U1.9 (XI), X1.2
unnamed: C8.2, U1.10 (XO), X1.1
unnamed: R3.2, TX.-
unnamed: Q1.1 (B), R1.2
unnamed: Q2.1 (B), R2.2
unnamed: R4.2, RX.-
unnamed: PWR.-, R5.2
PWRIN: D3.A, X3.2
RST: PCB1.RESET, U$3.RST, U$3.RST1
RTS: J3.7, U1.16 (RTS#)
RX: D1.2, J3.2, PCB1.0 (0(RX)), R2.1, U1.4 (RXD), U$3.RX1, U$3.RX1-1
SCK: U5.5 (+IN)
TX: D1.1, J3.3, PCB1.1 (1(TX)), R1.1, U1.3 (TXD), U$3.TX0, U$3.TX0-1
USBVCC: F1.1, T1.1 (D)
USHIELD: L1.2, X2.P$1, X2.P$2, Z1.2, Z2.2
V3: C7.1, U1.5 (V3)
VCC: PCB1.5V, U$3.VCC, U$3.VCC1
VIN: D3.C, PC1.+, PCB1.VIN, RN1.8 (2), U2.3 (IN), U$3.RAW
XUSB: F1.2, X2.1

Board: 2 copper layers, 40 parts (0 on the bottom side), 50 nets, no tracks yet.

## EAGLE design Eagle/f1_Not/NOT.brd

Parts:
C1: 0.1uF; 0603-CAP
H1, H3: HEAD_LOCK
IC2: TINY13-20SSU; 8S1
LED1: LEDSML0603; SML0603
R1: RESISTOR0603-RES; 0603-RES
U$1: DIMENSION1

Connections:
5V: C1.2, H1.2, H3.2, IC2.1 (PB5/PCINT5/!RESET!/ADC0/DW), IC2.8 (VCC), LED1.A
GND: C1.1, H1.3, H3.3, IC2.4 (GND), R1.1
IN1: H1.1, IC2.2 (PB3/PCINT3/CLKI/ADC3)
unnamed: LED1.C, R1.2
OUT: H3.1, IC2.5 (PB0/PCINT0/AIN0/OC0A/MOSI)

Board: 2 copper layers, 160.0 x 100.0 mm, 8 parts (0 on the bottom side), 5 nets.

Other parts of the board:
U$2: OSHW-LOGO-M

## EAGLE design Eagle/f2_OrAnd/AND_OR.brd

Parts:
C1: 0.1uF; 0603-CAP
H1, H2, H3: HEAD_LOCK
IC1: TINY13-20SSU; 8S1
LED1: LEDSML0603; SML0603
R1, R2: RESISTOR0603-RES; 0603-RES
S1: SWITCH-SPDTKIT; SWITCH-SPDT_KIT
U$2: XMAKERLOGO2
U$3: DIMENSION1
U$4: OPENHARDWARE

Connections:
5V: C1.2, H1.2, H2.2, H3.2, IC1.1 (PB5/PCINT5/!RESET!/ADC0/DW), IC1.8 (VCC), LED1.A, R2.2
GND: C1.1, H1.3, H2.3, H3.3, IC1.4 (GND), R1.1, S1.3 (S)
IN1: H1.1, IC1.2 (PB3/PCINT3/CLKI/ADC3)
IN2: H2.1, IC1.3 (PB4/PCINT4/ADC2)
unnamed: LED1.C, R1.2
unnamed: R2.1, S1.1 (O)
OUT: H3.1, IC1.5 (PB0/PCINT0/AIN0/OC0A/MOSI)
SELECT: IC1.7 (PB2/PCINT2/SCK/ADC1/T0), S1.2

Board: 2 copper layers, 160.0 x 100.0 mm, 12 parts (0 on the bottom side), 8 nets.

## EAGLE design Eagle/f4_Delay/DELAY.brd

Parts:
C2: 0.1uF; 0603-CAP
H1, H2: HEAD_LOCK
IC1: TINY13-20SSU; 8S1
LED2: LED_ESML0603; LED_SML0603
R1: RESISTOR0603-RES; 0603-RES
R2: 3RP/1610N
R3: 0.27OHM-1/10W-1%(0603); 0603-RES
S1: SWITCH-SPDTKIT; SWITCH-SPDT_KIT
U$1: XMAKERLOGO2
U$2: DIMENSION1
U$3: OPENHARDWARE

Connections:
CONTROL: IC1.3 (PB4/PCINT4/ADC2), R2.2 (S)
DELAY: H2.1, IC1.5 (PB0/PCINT0/AIN0/OC0A/MOSI)
GND: C2.2, H1.3, H2.3, IC1.4 (GND), R2.1 (A), R3.1, S1.3 (S)
IN: H1.1, IC1.2 (PB3/PCINT3/CLKI/ADC3)
unnamed: R1.1, S1.1 (O)
unnamed: LED2.C, R3.2
SELECT: IC1.7 (PB2/PCINT2/SCK/ADC1/T0), S1.2
VCC: C2.1, H1.2, H2.2, IC1.1 (PB5/PCINT5/!RESET!/ADC0/DW), IC1.8 (VCC), LED2.A, R1.2, R2.3 (E)

Notes on the sheet:
0.1秒

Board: 2 copper layers, 160.0 x 100.0 mm, 12 parts (0 on the bottom side), 8 nets.

## EAGLE design Eagle/f5_Count/COUNT.brd

Parts:
C2: 0.1uF; 0603-CAP
H4, H5: HEAD_LOCK
IC1: TINY13-20SSU; 8S1
LED2: LED_ESML0603; LED_SML0603
R1: RESISTOR0603-RES; 0603-RES
R2: 3RP/1610N
R3: 0.27OHM-1/10W-1%(0603); 0603-RES
S1: TAC_SWITCHKSA_SEALED; KSA_SEALED_TAC_SWITCH
U$1: DIMENSION1

Connections:
CONTROL: IC1.3 (PB4/PCINT4/ADC2), R2.2 (S)
GND: C2.2, H4.3, H5.3, IC1.4 (GND), R2.1 (A), R3.1, S1.P$3 (3), S1.P$4 (4)
IN: H4.1, IC1.2 (PB3/PCINT3/CLKI/ADC3)
unnamed: LED2.C, R3.2
OUT: H5.1, IC1.5 (PB0/PCINT0/AIN0/OC0A/MOSI)
SELECT: IC1.7 (PB2/PCINT2/SCK/ADC1/T0), R1.1, S1.P$1 (1), S1.P$2 (2)
VCC: C2.1, H4.2, H5.2, IC1.1 (PB5/PCINT5/!RESET!/ADC0/DW), IC1.8 (VCC), LED2.A, R1.2, R2.3 (E)

Notes on the sheet:
0.1秒

Board: 2 copper layers, 160.0 x 100.0 mm, 11 parts (0 on the bottom side), 7 nets.

Other parts of the board:
U$2: OSHW-LOGO-M

## EAGLE design Eagle/f6_Pluse/f6_Pluse.brd

Parts:
C1: 0.1uF; 0603-CAP
H1, H2: HEAD_LOCK
IC1: TINY13-20SSU; 8S1
LED1: LED_ESML0603; LED_SML0603
R2: 0.27OHM-1/10W-1%(0603); 0603-RES
U$1: POL_CIRCLE; POT_CIRCLE
U$2: XMAKERLOGO2
U$3: DIMENSION1
U$4: OPENHARDWARE

Connections:
ADC: H1.1, IC1.2 (PB3/PCINT3/CLKI/ADC3)
CONTROL: IC1.3 (PB4/PCINT4/ADC2), U$1.P$2 (2)
GND: C1.2, H1.3, H2.3, IC1.4 (GND), R2.1, U$1.P$3 (3)
unnamed: LED1.C, R2.2
PWM: H2.1, IC1.5 (PB0/PCINT0/AIN0/OC0A/MOSI)
VCC: C1.1, H1.2, H2.2, IC1.1 (PB5/PCINT5/!RESET!/ADC0/DW), IC1.8 (VCC), LED1.A, U$1.P$1 (1)

Board: 2 copper layers, 10 parts (0 on the bottom side), 6 nets, no tracks yet.

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
